# Repository thaaraak/IRF510-Amplifier-v2

## KiCad design IRF510-Amplifier.kicad_pcb

Board: 2 copper layers, 126.4 x 81.6 mm, 57 parts (4 on the bottom side), 28 nets.

Parts:
 : MountingHole_3.5mm
 #2,  #3,  #4: MountingHole_3.5mm
C1, C2, C4, C6, C9, C10, C12, C13, C15, C17, C53, C57: .1uF; Capacitor 0805
C3, C8: 150p; Capacitor 1206
C5: 330p; Capacitor 1206
C7: 33p; Capacitor 1206
C11: 100uF; Cap_6.3x5.4
C14, C16: 22uF; Cap_4x5.4
D1: D_Zener; D_A-405_P10.16mm_Horizontal
J1: Jack-DC; BarrelJack_Horizontal
J2, J3: BNC
J4: Audio_Jack
L1: T50-43 10T; T50_Inductor
L3: 14T T37-6; T37_Inductor
L4: 18T T37-6; T37_Inductor
Q1: 2N3904-SMD; SOT-23
Q2: 2SC5706; TO-252-2
Q3: BS170F; SOT-23
Q4: IRF510; TO-220-3_Vertical
Q5: IRFU9024; TO-251-3_Vertical
R1: 33; Resistor 0805
R2: 10; Resistor 0805
R3, R4, R7: 10k; Resistor 0805
R5: 1.5k; Resistor 0805
R6, R10: 62; Resistor 0805
R8, R65: 1k; Resistor 0805
R9: 2.7k; Resistor 0805
R11, R12: 18; Resistor 0805
R52: 24k; Resistor 0805
R53: 6.8k; Resistor 0805
R64: 4.7k; Resistor 0805
RV1, RV2: R_POT; Trimpot Vertical
T1: T37-43 8T:4T; T37 Transformer
T2: T37-43 25T:8T; T37 Transformer
U6: MCP1703A-2502_SOT223; TO-252-3_TabPin2

Connections:
12V-On: C16.1, C17.1, C53.1, Q5.2, R52.1, R64.1, T1.C1B, T2.C1B, U6.1
+5V: C10.1, C14.1, RV2.3, U6.3
+12V: C4.1, C11.1, J1.1, L1.1, Q5.3, R4.1
GND: C3.2, C4.2, C5.2, C6.2, C8.2, C10.2, C11.2, C14.2, C16.2, C17.2, C53.2, J1.2, J2.GND, J3.GND, J4.SLEEVE, Q3.2, Q4.3, R1.2, R2.2, R3.1, R6.2, R8.2, R10.2, R11.2, R12.2, R53.2, R65.2, RV2.1, T1.C2A, T2.C2A, U6.2
unnamed: C1.1, R8.1, T1.C2B
unnamed: C1.2, RV1.3
unnamed: C2.1, R1.1, RV1.2
unnamed: C2.2, D1.1, Q4.1, R9.2
unnamed: C3.1, C57.2, L3.1
unnamed: C5.1, C7.2, L3.2, L4.1
unnamed: C6.1, Q3.1, R5.1
unnamed: C7.1, C8.1, J2.S, L4.2
unnamed: C9.1, J3.S
unnamed: C9.2, Q1.1, R64.2, R65.1
unnamed: C12.1, Q1.2, R6.1
unnamed: C12.2, R10.1
unnamed: C13.1, T2.C2B
unnamed: C13.2, Q2.1, R52.2, R53.1
unnamed: C15.1, Q2.3, R11.1
unnamed: C15.2, R12.1
unnamed: C57.1, L1.2, Q4.2
unnamed: D1.2, R2.1
unnamed: J4.RING, J4.RSH, J4.TIP, J4.TSH, R3.2, R5.2
unnamed: Q1.3, T2.C1A
unnamed: Q2.2, T1.C1A
unnamed: Q3.3, R7.2
unnamed: Q5.1, R4.2, R7.1
unnamed: R9.1, RV2.2

## Commit log

2021-07-24 fixed q2
2021-07-25 fix gain pot
2021-07-25 added ltspice
2021-07-25 added pdf
2021-07-25 added gerber
2021-08-14 added csv
